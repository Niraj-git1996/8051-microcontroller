# Keil uVision project LCD_inerfacing.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: LCD_inerfacing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Driver's
    ./: io_write.c delay.c lcd_driver.c cgram.c lcd_4bit.c
  group Applications
    ./: header.h main.c
